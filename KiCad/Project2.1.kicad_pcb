# Repository tubeFUN/GasWS

File README.md:

# Project Name
> Gas Warning System (GWS)

## Table of contents
* [General info](#general-info)
* [Screenshots](#screenshots)
* [Technologies](#technologies)
* [Setup](#setup)
* [Features](#features)
* [Status](#status)
* [Inspiration](#inspiration)
* [Parts and footprints list](#Parts-and-footprints-list)
* [Allowed (planned) SMS commands](#Allowed-(planned)-SMS-commands)
* [Principle of operation](#principle-of-operation)
* [Contact](#contact)

## General info
From scratch self-made home alarm system with gas sensor to ensure the safety of residents.
Adaptable system can be modified to gather information from other sensors like flood, carbon monoxide, etc according to residents demends.
System board is powered from the power supply or from battery in case of power failure.
Information about exceed sensor value is send to declared phone number via SMS.

## Screenshots

3D wiew of PCB top side. PCB version 2.1

Real wiew of PCB top side. PCB version 1.0

3D wiew of PCB bottom side. PCB version 2.1

Real wiew of PCB bottom side. PCB version 1.0

View of the ready PCB, version 1.0.

## Technologies
* Arduino 1.8.10 as an IDE
* Arduino Mega 2560 as a testing board
* MQ-2 Gas Sensor
* SIM800C 2G module
* KiCad 5.1.4 as EDA Suite
* freeRouting.jar as an autorouter
* USBASP v2.0 as a target programmer
* AVRdude v6.3

## Setup
In the first step, enter the phone number on line 19 of the Gas_warning_system_v21.ino file to which SMS notifications will be sent. Then prepare the Arduino IDE. To receive long SMS (160 characters) it is needed to extend serials buffer size. To do this in the location:  
"C:\Program Files(x86)\Arduino\hardware\arduino\avr\cores\arduino\HardwareSerial.h  
change buffer size to:  
#define SERIAL_TX_BUFFER_SIZE 254  
#define SERIAL_RX_BUFFER_SIZE 254  

In the next step, you need to compile the code in the Arduino IDE and export it to the .hex format, use the keyboard shortcut Ctrl + Alt + S. The imported files will appear in the folder in which we placed the Gas_warning_system_v21.ino file. We are interested in the Gas_warning_system_v21.ino.mega.hex file, which does not contain a bootloader. This file is uploaded to the microcontroller using the ISP programmer. I use USBAsp in combination with avrdude. If you prefer to use the "windows", I recommend the avrdude graphic overlay called AVRDUDESS 2.11. The Arduino IDE also allows programming of microcontrollers using an external programmer (USBasp), by the way, it uses avrdude. 
Finally, set the fusebits.  

Default ATmega2560 fuses & lock bits:  
L 0x62  
H 0x99  
E 0xFF  
LB 0x3F  

GWS ATmega2560 fuses & lock bits:  
L 0xFF  
H 0xD8  
E 0xFC  
LB 0x3F  
and you can enjoy a working alarm control system.

## Code Examples

Screenshot of SMS communication with GWS.

## Features
List of features ready and TODOs for future development
* Adaptable system, 16 additional GPIO ports for future use
* All modules (uC, converters, GSM modem, buffer power supply with battery) on one PCB
* Battery powered system as a backup with protection circuit
* System monitoring by LED indicators and via USB (virtual COM in OS, adjustable baud rate)
* Alarming by SMS, sound (buzzer) and visually
* Reset switch
* In system programming by USBASP 

To-do list:
* Adding USSD code support
* Improving the readability of the code
* Check the program's resistance to incorrectly entered data
* Adding more sensors and appropriate code

## Status
Project is done.

## Inspiration
Project is based on... my need and to refresh my abilities.

## Parts and footprints list

## Allowed SMS commands to Gas Warning System
* Halt - Stops the system
* Start - Starts the system
* Level - Sends an SMS with the current gas level
* Status - Sends an SMS with with the current date, time and gas level
* Account - Account balance (to do)

## Principle of operation

PCB consists of five functional blocks, two DC/DC converters, GSM modem, USB to UART interface, microcontroller with peripherals.
First DC/DC converter (charger) based on TP4056 chip converts 5V DC from the power supply to voltage required by single cell Li-Ion battery (18650 type 2600mAh). The charge voltage is set to 4.2V and the charge current is set by R25 resistor to 1000 mA value. Chip automaticaly terminates the charge cycle when the charge current drops to 1/10th programed value after final float voltage is reached. Batttery is protected from over-discharge and overcharge by DW01A chip. Over-discharge protection - keeps battery from being discharged below 2.4V. Module will cut output power from the battery until the battery voltage has been re-charged above 3.0V. During battery charging TP4056 chip may produce a lot of heat. To dissipate heat a few vias ond copper layer were placed under chip body.

Second converter based on LT1308 is a step-up DC/DC converter. It was design to converts voltage from single Li-Ion to 5V 1A. In Gas Warning System board this voltage is used by USB to UART interface and microcontroller with peripherals blocks.

USB to UART interface is based on well known FT232 chip. It interfaces between USB and Atmega2560 uC UART. In the Windows 10 operating system board is recognised as virtual port (COMx). Driver is installed automaticaly. This feature allows to comunicate with uC from Arduino IDE and monitor Gas Warning System status.

GSM block is based on SIM800C modem. Communication with uC is realized by UART1 (build in the module). AT commands had been succesfully used. Bidirectional logic level conversion was needed to satisfy chips needs. BSS138 transistors had been used to translate between 5V and 4,2V levels. SIM800C is 2G (GSM) generation and uses 900MHz frequency (used in Poland). Three other bands are supported (850, 1800, 1900 MHz) by this module. Transient overvoltage protection has been used to protect ESD component (SIM800C) in signal lines from SIM card.

ATmega2560 is the heart of the system. The same uC is used in Arduino Mega board. uC block is equipped with LEDs, tact switches, buzzer and of course connectors to communicate with sensors like MQ-2 Gas Sensor. Peripherals help user to indicate actual state of the system, do some simple actions or react to alarm. Chip programing is possible via ISP method.

Transistors Q1 and Q3 with neighboring elements perform level conversion between UART (5V) and SIM800C modem (4V). The Q2 circuit is used to enable the SIM800C modem.

## Contact
vacuum.tube.fun@gmail.com

## KiCad design KiCad/Project2.1.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_1042_1x18650
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 470uF Tantal ESR; CP_EIA-7343-31_Kemet-D
C2: 1uF; C_1206_3216Metric
C3: 33pF; C_1206_3216Metric
C4: 4,7u; CP_EIA-3216-18_Kemet-A
C5, C6, C7: 22p; C_1206_3216Metric
C8, C11, C15, C16, C18, C19: 100nF; C_1206_3216Metric
C9: 100nF; R_1206_3216Metric
C10, C21: 470uF ESR; CP_Elec_8x10.5
C12: 470uF; CP_EIA-7343-31_Kemet-D
C13: 100p; C_1206_3216Metric
C14: 100uF; CP_EIA-7343-31_Kemet-D
C17: 22p; C_0805_2012Metric
C20: 47uF; C_1210_3225Metric
D1: 5V1; SOD-80
D2: ESD; SOT-23-6
D3: Alarm LED; D_1206_3216Metric
D4: VS-10BQ015-M3_5BT; DIOM5436X244N; Manufacturer_Part_Number VS-10BQ015-M3/5BT; Mouser Part Number 78-VS-10BQ015-M35BT
D5: RX; D_1206_3216Metric
D6: TX; D_1206_3216Metric
D7: LL4148; SOD-80
D8: System Status; D_1206_3216Metric
D9: PWR; D_1206_3216Metric
D10: CHRG; D_1206_3216Metric
D11: LXES; D_SMA
D12: Modem Status; D_1206_3216Metric
D13: NET; D_1206_3216Metric
D14: RF; D_1206_3216Metric
F1: 2A; Fuse_2920_7451Metric
IC1: LT1308; SOIC127P599X175-8N; Manufacturer_Part_Number LT1308ACS8#PBF; Mouser Part Number 584-LT1308ACS8#PBF
IC2: TP4056; SOP-8
IC3: DW01A-G; SOT95P190X145-6N; Manufacturer_Part_Number DW01A-G
ISP1: AVRISP
J2: 282836-9; SHDR9W130P0X500_1X9_4500X820X1020P; Manufacturer_Part_Number 282836-9; Mouser Part Number 571-282836-9
J3: Gas Sensor; SHDR3W100P0X500_1X3_1500X760X1020P
J4: Digital; CONN-100MIL-F-1x8
J5: SIM; 475531001; Mouser Part Number 538-47553-1001
J6: Conn_Coaxial; SMA_Amphenol_132134_Vertical
J7: USB; 101181940011LF; Manufacturer_Part_Number 10118194-0011LF; Mouser Part Number 649-10118194-0011LF
J8: Power; SHDR3W100P0X500_1X3_1500X760X1020P
J9: Power 5V DC; CONSOCJ2155; Manufacturer_Part_Number CON-SOCJ-2155; Mouser Part Number 992-CON-SOCJ-2155
L1: 4,7uH; LQH55DN100M03L
Q1, Q3: BSS138; SOT-23_Handsoldering
Q2: BC847; SOT-23_Handsoldering
Q4: FS8205A; SOP65P640X120-8N; Manufacturer_Part_Number FS8205A
R1, R3, R4, R5, R11, R20: 10k; R_1206_3216Metric
R2, R10: 4,7k; R_1206_3216Metric
R6, R13: 47k; R_1206_3216Metric
R7, R8, R9: 51R; R_1206_3216Metric
R12, R16, R17, R18, R19, R21, R23, R24, R26, R27, R28, R29: 1k; R_1206_3216Metric
R14: 309k; R_1206_3216Metric
R15: 100k; R_1206_3216Metric
R22: 1M; R_1206_3216Metric
R25: 1.2k; R_1206_3216Metric
R30: 100R; R_1206_3216Metric
SW1: SW_DIP_x01; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW2: Alarm Reset; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: ATmega2560-16AU; TQFP-100_14x14mm_P0.5mm
U2: SIM800C; SIMCom_SIM800C
U3: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm
Y1: CSTCE16M0V53-R0; OSC_CSTCE16M0V53-R0

Connections:
+4V: BT1.1 (+), C1.1, C2.1, C3.1, C8.1, C10.1, C12.1, C20.1, D1.1 (K), IC1.3, IC1.6, IC2.5 (BAT), L1.1, R30.1, U2.34 (VBAT), U2.35 (VBAT)
+5V: C14.1, C15.1, D4.1, D7.1 (K), ISP1.2 (VCC), J3.3, R4.2, R5.2, R14.1, R17.1, R19.1, R20.1, U1.10 (VCC), U1.31 (VCC), U1.61 (VCC), U1.80 (VCC), U1.100 (AVCC), U3.4 (VCCIO), U3.20 (VCC)
+5VA: C18.2, C21.1, D9.2 (A), D10.2 (A), F1.2, IC2.4 (VCC), IC2.8 (CE)
unnamed: BT1.2 (-), C19.1, IC3.6 (GND), Q4.2 (S1_1), Q4.3 (S1_2)
unnamed: BZ1.2 (+), U1.24 (PB5)
unnamed: C4.1, U2.28 (VRTC)
unnamed: C5.1, D2.6 (IO5), R9.2, U2.15 (SIM_DATA)
unnamed: C6.1, R8.2, U2.16 (SIM_CLK)
unnamed: C7.1, R7.2, U2.17 (SIM_RST)
unnamed: C9.1, D2.1 (IO1), J5.1 (C1), U2.18 (SIM_VDD)
unnamed: C11.1, U3.17 (3V3OUT)
unnamed: C13.1, R13.2
unnamed: C16.1, U1.98 (AREF)
unnamed: C17.1, D7.2 (A), ISP1.5 (RST), R20.2, SW1.2, U1.30 (~RESET)
unnamed: C19.2, IC3.5 (VCC), R30.2
unnamed: D3.2 (A), R12.1
unnamed: D4.2, IC1.5, L1.2
unnamed: D5.1 (K), U3.22 (CBUS1)
unnamed: D5.2 (A), R17.2
unnamed: D6.1 (K), U3.23 (CBUS0)
unnamed: D6.2 (A), R19.2
unnamed: D8.2 (A), R21.1
unnamed: D9.1 (K), R23.2
unnamed: D10.1 (K), R24.2
unnamed: D11.1 (K), J6.1 (In), U2.32 (GSM_ANT)
unnamed: D12.2 (A), R27.1
unnamed: D13.2 (A), R28.1
unnamed: D14.2 (A), R29.1
unnamed: F1.1, J8.1, J9.1
unnamed: IC1.1, R13.1
unnamed: IC1.2, R14.2, R15.1
unnamed: IC2.2 (PROG), R25.2
unnamed: IC2.6 (STDBY), R23.1
unnamed: IC2.7 (CHRG), R24.1
unnamed: IC3.1 (OD), Q4.4 (G1)
unnamed: IC3.2 (CS), R26.2
unnamed: IC3.3 (OC), Q4.5 (G2)
unnamed: ISP1.1 (MISO), U1.22 (PB3)
unnamed: ISP1.3 (SCK), U1.20 (PB1)
unnamed: ISP1.4 (MOSI), U1.21 (PB2)
unnamed: J2.1, U1.82 (PK7)
unnamed: J2.2, U1.83 (PK6)
unnamed: J2.3, U1.84 (PK5)
unnamed: J2.4, U1.85 (PK4)
unnamed: J2.5, U1.86 (PK3)
unnamed: J2.6, U1.87 (PK2)
unnamed: J2.7, U1.88 (PK1)
unnamed: J2.8, U1.89 (PK0)
unnamed: J3.2, U1.97 (PF0)
unnamed: J4.1, U1.78 (PA0)
unnamed: J4.2, U1.77 (PA1)
unnamed: J4.3, U1.76 (PA2)
unnamed: J4.4, U1.75 (PA3)
unnamed: J4.5, U1.74 (PA4)
unnamed: J4.6, U1.73 (PA5)
unnamed: J4.7, U1.72 (PA6)
unnamed: J4.8, U1.71 (PA7)
unnamed: J7.1, R10.1
unnamed: J7.2, U3.16 (USBD-)
unnamed: J7.3, U3.15 (USBD+)
unnamed: Q1.1 (G), Q3.1 (G), R1.1, R3.1, U2.40 (VDD_EXT)
unnamed: Q1.2 (S), R1.2, U2.2 (UART1_RXD)
unnamed: Q2.1 (B), R2.1, R6.2
unnamed: Q2.3 (C), U2.39 (~PWRKEY)
unnamed: Q3.2 (S), R3.2, U2.1 (UART1_TXD)
unnamed: R2.2, U1.15 (PH3)
unnamed: R10.2, R11.1, U3.19 (~RESET~)
unnamed: R12.2, U1.23 (PB4)
unnamed: R16.1, U3.1 (TXD)
unnamed: R16.2, U1.2 (PE0)
unnamed: R18.1, U3.5 (RXD)
unnamed: R18.2, U1.3 (PE1)
unnamed: R21.2, U1.18 (PH6)
unnamed: R22.1, U1.33 (XTAL2), Y1.3
unnamed: R22.2, U1.34 (XTAL1), Y1.1
unnamed: R27.2, U2.42 (STATUS)
unnamed: R28.2, U2.41 (NETLIGHT)
unnamed: R29.2, U2.29 (RF_SYNC)
unnamed: SW2.1, U1.17 (PH5)
UART_RXD: Q1.3 (D), R5.1, U1.46 (PD3)
UART_TXD: Q3.3 (D), R4.1, U1.45 (PD2)

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
Board: 2 copper layers, 147.3 x 116.8 mm, 91 parts (0 on the bottom side), 85 nets.

File Parts_list.txt:

Reference	 Value	 Footprint
U2	SIM800C	RF_GSM:SIMCom_SIM800C
R3	10k	Resistor_SMD:R_1206_3216Metric
R4	10k	Resistor_SMD:R_1206_3216Metric
R5	10k	Resistor_SMD:R_1206_3216Metric
R1	10k	Resistor_SMD:R_1206_3216Metric
C1	470uF Tantal ESR	Capacitor_Tantalum_SMD:CP_EIA-7343-31_Kemet-D
C3	33pF	Capacitor_SMD:C_1206_3216Metric
C2	1uF	Capacitor_SMD:C_1206_3216Metric
D1	5V1	smd-semi:SOD-80
C8	100nF	Capacitor_SMD:C_1206_3216Metric
C10	470uF ESR	Capacitor_SMD:CP_Elec_8x10.5
Q2	BC847	Package_TO_SOT_SMD:SOT-23_Handsoldering
R6	47k	Resistor_SMD:R_1206_3216Metric
R2	4,7k	Resistor_SMD:R_1206_3216Metric
C4	4,7u	Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A
Q3	BSS138	Package_TO_SOT_SMD:SOT-23_Handsoldering
Q1	BSS138	Package_TO_SOT_SMD:SOT-23_Handsoldering
R9	51R	Resistor_SMD:R_1206_3216Metric
R8	51R	Resistor_SMD:R_1206_3216Metric
R7	51R	Resistor_SMD:R_1206_3216Metric
C5	22p	Capacitor_SMD:C_1206_3216Metric
C7	22p	Capacitor_SMD:C_1206_3216Metric
C9	100nF	Resistor_SMD:R_1206_3216Metric
D2	ESD	Package_TO_SOT_SMD:SOT-23-6
C6	22p	Capacitor_SMD:C_1206_3216Metric
R28	1k	Resistor_SMD:R_1206_3216Metric
R27	1k	Resistor_SMD:R_1206_3216Metric
D12	Modem Status	Diode_SMD:D_1206_3216Metric
D13	NET	Diode_SMD:D_1206_3216Metric
R29	1k	Resistor_SMD:R_1206_3216Metric
D14	RF	Diode_SMD:D_1206_3216Metric
J6	Conn_Coaxial	Connector_Coaxial:SMA_Amphenol_132134_Vertical
D11	LXES	Diode_SMD:D_SMA
Y1	CSTCE16M0V53-R0	CSTCE16M0V53-R0:OSC_CSTCE16M0V53-R0
R22	1M	Resistor_SMD:R_1206_3216Metric
C15	100nF	Capacitor_SMD:C_1206_3216Metric
J4	Digital	conn-100mil:CONN-100MIL-F-1x8
ISP1	AVRISP	AVRISP:AVRISP
IC2	TP4056	TP4056:SOP-8
IC3	DW01A-G	DW01A-G:SOT95P190X145-6N
Q4	FS8205A	FS8205A:SOP65P640X120-8N
R24	1k	Resistor_SMD:R_1206_3216Metric
R23	1k	Resistor_SMD:R_1206_3216Metric
D9	PWR	Diode_SMD:D_1206_3216Metric
D10	CHRG	Diode_SMD:D_1206_3216Metric
C18	100nF	Capacitor_SMD:C_1206_3216Metric
C19	100nF	Capacitor_SMD:C_1206_3216Metric
R30	100R	Resistor_SMD:R_1206_3216Metric
R26	1k	Resistor_SMD:R_1206_3216Metric
R25	1.2k	Resistor_SMD:R_1206_3216Metric
BT1	Battery_Cell	Battery:BatteryHolder_Keystone_1042_1x18650
C20	47uF	Capacitor_SMD:C_1210_3225Metric
IC1	LT1308	LT1308ACS8#PBF:SOIC127P599X175-8N
L1	4,7uH	LQH55DN4R7M03L:LQH55DN100M03L
R15	100k	Resistor_SMD:R_1206_3216Metric
R14	309k	Resistor_SMD:R_1206_3216Metric
R13	47k	Resistor_SMD:R_1206_3216Metric
C13	100p	Capacitor_SMD:C_1206_3216Metric
C14	100uF	Capacitor_Tantalum_SMD:CP_EIA-7343-31_Kemet-D
C12	470uF	Capacitor_Tantalum_SMD:CP_EIA-7343-31_Kemet-D
R18	1k	Resistor_SMD:R_1206_3216Metric
R16	1k	Resistor_SMD:R_1206_3216Metric
R19	1k	Resistor_SMD:R_1206_3216Metric
R17	1k	Resistor_SMD:R_1206_3216Metric
D6	TX	Diode_SMD:D_1206_3216Metric
D5	RX	Diode_SMD:D_1206_3216Metric
R10	4,7k	Resistor_SMD:R_1206_3216Metric
R11	10k	Resistor_SMD:R_1206_3216Metric
C11	100nF	Capacitor_SMD:C_1206_3216Metric
BZ1	Buzzer	Buzzer_Beeper:Buzzer_12x9.5RM7.6
SW2	Alarm Reset	Button_Switch_SMD:SW_Push_1P1T_NO_6x6mm_H9.5mm
R21	1k	Resistor_SMD:R_1206_3216Metric
D8	System Status	Diode_SMD:D_1206_3216Metric
R12	1k	Resistor_SMD:R_1206_3216Metric
D3	Alarm LED	Diode_SMD:D_1206_3216Metric
J3	Gas Sensor	CTB5202_3:SHDR3W100P0X500_1X3_1500X760X1020P
C16	100nF	Capacitor_SMD:C_1206_3216Metric
F1	2A	Fuse:Fuse_2920_7451Metric
U3	FT232RL	Package_SO:SSOP-28_5.3x10.2mm_P0.65mm
J2	282836-9	282836-9:SHDR9W130P0X500_1X9_4500X820X1020P
J9	Power 5V DC	CON-SOCJ-2155:CONSOCJ2155
J8	Power	CTB5202_3:SHDR3W100P0X500_1X3_1500X760X1020P
J7	USB	10118194-0011LF:101181940011LF
C21	470uF ESR	Capacitor_SMD:CP_Elec_8x10.5
D4	VS-10BQ015-M3_5BT	VS-10BQ015-M3_5BT:DIOM5436X244N
C17	22p	Capacitor_SMD:C_0805_2012Metric
R20	10k	Resistor_SMD:R_1206_3216Metric
D7	LL4148	smd-semi:SOD-80
SW1	SW_DIP_x01	Button_Switch_SMD:SW_Push_1P1T_NO_6x6mm_H9.5mm
U1	ATmega2560-16AU	Package_QFP:TQFP-100_14x14mm_P0.5mm
J5	SIM	47553-1001:475531001

## Commit log

2019-12-01 First repository
2019-12-03 Editing corrections
2019-12-05 Complite .md file
2019-12-10 Small changes
2019-12-10 Adding additional descriptions
2019-12-10 Adding parts list
2019-12-10 Adding screenshots
2019-12-10 Adding commands
2019-12-10 New bullets
2019-12-16 RESET net correction
2019-12-18 Adding control over SMS
2019-12-21 Controling via SMS
2019-12-21 To Do addings
2019-12-23 Improve copper fills, antenna treck, add vias, correct RESET track
2019-12-23 Adding real photos of PCB version 1.0
2019-12-28 Version 2.0
2019-12-28 Adding Principle of operation
2020-01-14 Setup instruction
2020-01-14 Setup changes
2020-01-14 Q1, Q2 and Q3 use explanation.
2020-01-15 Adding screenshot
2020-01-15 Screenshot resize
2020-01-22 Update Gas_warning_system_v21.ino
    Add power up procedure
2020-01-26 Fix #1 issue
